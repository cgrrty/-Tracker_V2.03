# IAR project Gzq.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCIncludePath2: ; app; library; library\inc; linker; startup
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Gzq.hex
  ILINK.IlinkOutputFile: Gzq.out
  ILINK.IlinkIcfFile: linker\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    app/: main.c my32x.c mym10.c myusart.c
  group library
    library/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group library/inc
    library/inc/: cortexm3_macro.h stm32f10x_dbgmcu.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h
  group library/src
    library/src/: stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group startup
    startup/: cortexm3_macro.s stm32f10x_vector.c
